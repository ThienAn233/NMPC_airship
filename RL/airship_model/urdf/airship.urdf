Commit message: modify env

File: RL/airship_model/urdf/airship.urdf (robot description, URDF)
Before this commit: robot airship, 1 links, 0 joints
Links:
- link base_link: mass 474.181 -> 2934
